# Keil uVision project major.uvproj, settings and files
target Target 1 (ARM-ADS)
  device: LPC2148 NXP
  cpu: IRAM(0x40000000-0x40007FFF) IROM(0-0x7FFFF) CLOCK(12000000) CPUTYPE(ARM7TDMI)
  output: major
  c flags: Optim=1
  memory RVCT4: ROM 0x0 size 0x80000
  memory RVCT9: RAM 0x40000000 size 0x8000
  group Source Group 1
    ./: Startup.s adc.c adc.h arduino.c delay.c kpm.c lcd.c major_main.c pin_connect_block.c rtc.c spi.c spi_eeprom.c system.c uart0.c system.h uart0.h uart_defines.h pin_functions_defines.h ESp01_2.c
